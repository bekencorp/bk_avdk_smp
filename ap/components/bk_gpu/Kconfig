## ap/components/bk_usb/CherryUSB_v1_6/tests/bouffalolab/Kconfig
```kconfig
# KCONFIG_GROUP: Demos::USB::CherryUSB
mainmenu "SDK Configuration"

source "$BL_SDK_BASE/Kconfig"
```
